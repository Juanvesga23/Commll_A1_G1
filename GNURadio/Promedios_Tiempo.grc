options:
  parameters:
    generate_options: qt_gui
    id: Promedios_de_Tiempos
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,1,1,0,0,0,-1,-1,-1,0,0,0)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):
          def __init__ ( self, additionFlag=True) : # only default arguments here
              gr. sync_block . __init__ (
                  self ,
                  name ='Promedios_de_tiempos', 
                  in_sig =[ np. float32 ],
                  out_sig =[ np. float32 , np.float32, np.float32, np.float32, np.float32]
              )
              self . acum_anterior = 0
              self . Ntotales = 0
              self . acum_anterior1 = 0
              self . acum_anterior2 = 0
              
          def work (self , input_items , output_items ):
              x = input_items [0] # Senial de entrada .
              y0 = output_items [0] # Promedio de la senial
              y1 = output_items [1] # Media de la senial
              y2 = output_items [2] # RMS de la senial
              y3 = output_items [3] # Potencia promedio de la senial
              y4 = output_items [4] # Desviacion estandar de la senial

              # Calculo del promedio
              N = len (x)
              self . Ntotales = self . Ntotales + N
              acumulado = self . acum_anterior + np. cumsum (x)
              self . acum_anterior = acumulado [N -1]
              y0 [:]= acumulado / self . Ntotales
              
              # Calculo de la media cuadratica
              x2=np. multiply (x,x)
              acumulado1 = self . acum_anterior1 + np. cumsum (x2)
              self . acum_anterior1 = acumulado [N -1]
              y1 [:] = acumulado1 / self . Ntotales
              
              # Calculo de la RMS
              y2 [:] = np. sqrt (y1)
              
              # Calculo de la potencia promedio
              y3 [:] = np. multiply (y2 ,y2)

              # Calculo de la desviacion estandar
              x3 = np. multiply (x-y0 ,x-y0)
              acumulado2 = self . acum_anterior2 + np. cumsum (x3)
              self . acum_anterior2 = acumulado2 [N -1]
              y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )
              
              return len (x)
              output_items[0][:]=input_items[0]*self.additionFlag
              return len (output_items[0])
    additionFlag: 'True'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: RMS
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media Cuadratica
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencial Promedio
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Desviacion Estandar
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Señal de Entrada
    size: '128'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_2, '0']
- [epy_block_0, '2', qtgui_number_sink_1, '0']
- [epy_block_0, '3', qtgui_number_sink_3, '0']
- [epy_block_0, '4', qtgui_number_sink_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
